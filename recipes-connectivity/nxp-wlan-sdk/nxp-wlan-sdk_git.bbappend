FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

require var-nxp-wlan-sdk_git.inc
